# IAR project Test_house_on_target.ewp, settings and files
configuration Test_house_on_target (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Test_house_on_target.hex
  ILINK.IlinkOutputFile: Test_house_on_target.out
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: app_x-cube-ai.c main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/CMSIS/DSP_Lib/Source/BasicMathFunctions
    ../Drivers/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_dot_prod_f32.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c
  group Lib
    ../Middlewares/ST/AI/AI/lib/: network_runtime.a
  group Middlewares/ST/AI/AI/data
    ../Middlewares/ST/AI/AI/data/: network_data.c
  group Middlewares/ST/AI/AI/src
    ../Middlewares/ST/AI/AI/src/: network.c
  group Middlewares/X-CUBE-AI/Artificial Intelligence/Application/Validation
    ../Middlewares/ST/Application/Validation/Src/: aiPbMgr.c aiTestUtility.c aiValidation.c pb_common.c pb_decode.c pb_encode.c stm32msg.pb.c
