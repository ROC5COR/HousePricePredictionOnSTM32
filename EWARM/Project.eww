<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Test_house_on_target.ewp</path>
  </project>
  <batchBuild />
</workspace>
